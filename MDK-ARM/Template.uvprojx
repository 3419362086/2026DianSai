# Keil uVision project Template.uvprojx, settings and files
target Template (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=8 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Module/0.91OLED;../User/Module/AHT20;../User/Module/BNO08x;../User/Module/Ebtn;../User/Module/GD25Qxx;../User/Module/Grayscale;../User/Module/ICM20608;../User/Module/PID;../User/Module/Ringbuffer;../User/Module/ZDT;../User/Module/Easy_Menu;../User/Module/PS2;../User/Driver;../User/App;../User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c rtc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User/Module/Ebtn
    ../User/Module/Ebtn/: ebtn.c
  group User/Module/Ringbuffer
    ../User/Module/Ringbuffer/: ringbuffer.c
  group User/Module/0.91 OLED
    ../User/Module/0.91OLED/: oled.c oledfont.c
  group User/Module/Grayscale
    ../User/Module/Grayscale/: hardware_iic.c
  group User/Module/ICM20608
    ../User/Module/ICM20608/: icm20608.c icm20608_iic.c
  group User/Module/PID
    ../User/Module/PID/: pid.c
  group User/Module/ZDT
    ../User/Module/ZDT/: Emm_V5.c
  group User/Module/BNO08x
    ../User/Module/BNO08x/: bno08x_hal.c
  group User/Module/AHT20
    ../User/Module/AHT20/: AHT20.c
  group User/Module/GD25Qxx
    ../User/Module/GD25Qxx/: gd25qxx.c
  group User/Module/Easy_Menu
    ../User/Module/Easy_Menu/: Easy_Menu.c Easy_Menu_Core.c Easy_Menu_Item.c Easy_Menu_Page.c Easy_Menu_User.c
  group User/Module/PS2
    ../User/Module/PS2/: pstwo.c
  group User/Driver
    ../User/Driver/: led_driver.c key_driver.c uart_driver.c oled_driver.c motor_driver.c encoder_driver.c gyroscope_driver.c zdt_motor_driver.c
  group User/App
    ../User/App/: led_app.c key_app.c uart_app.c oled_app.c gray_app.c motor_app.c encoder_app.c gyroscope_app.c pid_app.c zdt_motor_app.c aht20_app.c flash_app.c rtc_app.c
  group User
    ../User/: MyDefine.h Scheduler.c Scheduler_Task.c
software components: CMSIS:CORE 5.1.2
